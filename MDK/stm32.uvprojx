# Keil uVision project stm32.uvprojx, settings and files
target C16 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F107RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER\include;..\LIB\STM32F10x_StdPeriph_Driver\inc;..\LIB\CMSIS\CM3\CoreSupport;..\LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\LIB\STM32F10x_StdPeriph_Driver\src;..\USER\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/src/: main.c delay.c DMA.C KEY.C LED.C rc522.c SCI.c spi.c stm32f107.c ZQWL-Timer.c
  group INCLUDE
    ../USER/include/: delay.h DMA.H KEY.H LED.h main.h platform_config.h Printf.h rc522.h SCI.h spi.h stm32f10x_conf.h stm32f10x_it.h ZQWL-Timer.h
  group CMSIS
    ../LIB/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group LIB
    ../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../LIB/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group StartUp
    ../LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
